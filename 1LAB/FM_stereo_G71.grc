options:
  parameters:
    author: filipe
    generate_options: qt_gui
    id: file_testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FM_station
  id: variable_qtgui_range
  parameters:
    label: Seletor de Frequência
    start: '90000000'
    step: '100000'
    stop: '115000000'
    value: '103400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '19100'
    low_cutoff_freq: '18900'
    samp_rate: samp_rate2
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate2
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '25'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/filipe/Downloads/LEFT_POSD_1000Hz.dat
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/filipe/Downloads/IQ_104,3MHz.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate2
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: '500000'
    type: fir_filter_ccf
    width: '30000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate2
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '800'
    samp_rate: samp_rate2
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Importar o Sinal de Teste
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: FM_station
    fftsize: '1024'
    name: '"RF Monitor"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Left
    label2: Right
    nconnections: '2'
    size: '1024'
    srate: samp_rate2
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: FM_station
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: gpsdo
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: message
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: message
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: pilot_signal
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pilot_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}

connections:
- [analog_wfm_rcv_0, '0', virtual_sink_1_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', rational_resampler_xxx_2, '0']
- [blocks_delay_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', virtual_sink_1, '0']
- [blocks_file_source_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', high_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_1_0, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_2_0, '0']
- [high_pass_filter_0, '0', virtual_sink_2, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', blocks_delay_0, '0']
- [low_pass_filter_1_0, '0', virtual_sink_3, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_time_sink_x_0_1, '0']
- [rational_resampler_xxx_2_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_2_0, '0', qtgui_time_sink_x_0_1, '1']
- [rtlsdr_source_0, '0', qtgui_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', low_pass_filter_1, '0']
- [virtual_source_0_0, '0', band_pass_filter_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1, '0']
- [virtual_source_2, '0', band_pass_filter_0_0, '0']
- [virtual_source_3, '0', blocks_add_xx_0, '0']
- [virtual_source_3, '0', blocks_sub_xx_0, '0']
- [virtual_source_4, '0', blocks_add_xx_0, '1']
- [virtual_source_4, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
